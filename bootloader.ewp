# IAR project bootloader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE06Z128xxx4 NXP MKE06Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE06Z128VLK4; FRDM_KE06Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; frdmke06z/driver_examples/spi/interrupt_b2b_transfer/master; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: MKE06Z4/iar/MKE06Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKE06Z128VLK4; FRDM_KE06Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    board/: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_uart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MKE06Z4.h MKE06Z4_features.h system_MKE06Z4.c system_MKE06Z4.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_port.c fsl_port.h fsl_spi.c fsl_spi.h fsl_uart.c fsl_uart.h
  group MKE06Z4/iar
    MKE06Z4/iar/: MKE06Z128xxx4_flash.icf
  group source
    source/: flash_spi.c flash_spi.h headerFiles.h main.c variable.c variable.h
  group startup
    startup/: startup_MKE06Z4.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
